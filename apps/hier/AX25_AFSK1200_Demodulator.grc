<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AX25_AFSK_Demodulator</value></param>
<param><key>category</key><value>[Amateur]</value></param>
<param><key>description</key><value>Block to perform demodulation and deframing of AX.25 packets over AFSK1200.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AX.25 - AFSK1200 Demodulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_o</value></param>
<param><key>value</key><value>Rs * Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>max([1, min([20, int(Fs/Rs)])])</value></param>
</block>
<block>
<key>AFSK_Demodulator_BPF</key>
<param><key>id</key><value>AFSK_Demodulator_BPF_0</value></param>
<param><key>Rs</key><value>Rs</value></param>
<param><key>Mark</key><value>Mark</value></param>
<param><key>LoopBw</key><value>loopBw</value></param>
<param><key>MaxOffset</key><value>lockFreq</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>Sps</key><value>Sps</value></param>
<param><key>Space</key><value>Space</value></param>
</block>
<block>
<key>AX25_Deframer</key>
<param><key>id</key><value>AX25_Deframer_0</value></param>
</block>
<block>
<key>Digital_Down_Converter</key>
<param><key>id</key><value>Digital_Down_Converter_0</value></param>
<param><key>Fs_i</key><value>Fs</value></param>
<param><key>F_nco</key><value>0</value></param>
<param><key>Fs_o</key><value>Fs_o</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fs</value></param>
<param><key>label</key><value>Input Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Mark</value></param>
<param><key>label</key><value>Mark Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1200.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rs</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Space</value></param>
<param><key>label</key><value>Space Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2200.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>SRRC Roll-off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frameTag</value></param>
<param><key>label</key><value>Frame Tag</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lockFreq</value></param>
<param><key>label</key><value>PLL Maximum Deviation (rads)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0*math.pi/20.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>loopBw</value></param>
<param><key>label</key><value>PLL Loop Bandwidth (rads)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0*math.pi/100.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numSyms</value></param>
<param><key>label</key><value>SRRC Symbols</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>syms</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>pll</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>AFSK_Demodulator_BPF_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AFSK_Demodulator_BPF_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AFSK_Demodulator_BPF_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AX25_Deframer_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>Digital_Down_Converter_0</source_block_id><sink_block_id>AFSK_Demodulator_BPF_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Digital_Down_Converter_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>AX25_Deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>Digital_Down_Converter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
