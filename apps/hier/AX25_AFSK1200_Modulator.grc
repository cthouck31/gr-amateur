<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AX25_AFSK1200_Modulator</value></param>
<param><key>category</key><value>[Amateur]</value></param>
<param><key>description</key><value>Block to perform AX.25 packet transmission using AFSK1200.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AX.25 - AFSK1200 Modulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_in</value></param>
<param><key>value</key><value>Sps * Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_mod</value></param>
<param><key>value</key><value>R_arb * Fs_in</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>Fs / float(Sps * Rs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_arb</value></param>
<param><key>value</key><value>R / float(R_int)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_int</value></param>
<param><key>value</key><value>int(R)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>max([1, min([16, int(Fs/Rs)])])</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>interpTaps</value></param>
<param><key>cutoff_freq</key><value>0.5</value></param>
<param><key>gain</key><value>R_int</value></param>
<param><key>samp_rate</key><value>R_int</value></param>
<param><key>width</key><value>0.4</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>AX25_Framer</key>
<param><key>id</key><value>AX25_Framer_0</value></param>
<param><key>numPost</key><value>numPost</value></param>
<param><key>numRevs</key><value>numRevs</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fs</value></param>
<param><key>label</key><value>Output Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Mark</value></param>
<param><key>label</key><value>Mark Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1200.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rs</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Space</value></param>
<param><key>label</key><value>Space Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2200.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>SRRC Roll-off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>amateur_Burst_Afsk_Modulator</key>
<param><key>id</key><value>amateur_Burst_Afsk_Modulator_0</value></param>
<param><key>symRate</key><value>Rs</value></param>
<param><key>lengthTag</key><value>frameTag</value></param>
<param><key>markFreq</key><value>Mark</value></param>
<param><key>rrcAlpha</key><value>alpha</value></param>
<param><key>rrcSyms</key><value>numSyms</value></param>
<param><key>sps</key><value>Sps</value></param>
<param><key>spaceFreq</key><value>Space</value></param>
</block>
<block>
<key>amateur_Burst_Injector</key>
<param><key>id</key><value>amateur_Burst_Injector_0</value></param>
<param><key>lengthTag</key><value>frameTag</value></param>
</block>
<block>
<key>amateur_Burst_Stager</key>
<param><key>id</key><value>amateur_Burst_Stager_0</value></param>
<param><key>initDepth</key><value>65536</value></param>
<param><key>lengthTag</key><value>frameTag</value></param>
<param><key>maxDepth</key><value>-1</value></param>
<param><key>rate</key><value>R_arb</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1.0*dcInsert</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5 if (dcInsert != 0) else 1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dcInsert</value></param>
<param><key>label</key><value>DC Insert</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frameTag</value></param>
<param><key>label</key><value>Frame Tag</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>R_int</value></param>
<param><key>taps</key><value>interpTaps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numPost</value></param>
<param><key>label</key><value>Postamble Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numRevs</value></param>
<param><key>label</key><value>Preamble Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numSyms</value></param>
<param><key>label</key><value>SRRC Symbols</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>mod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>mod</value></param>
</block>
<connection><source_block_id>AX25_Framer_0</source_block_id><sink_block_id>amateur_Burst_Afsk_Modulator_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>amateur_Burst_Afsk_Modulator_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amateur_Burst_Injector_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amateur_Burst_Stager_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>amateur_Burst_Stager_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AX25_Framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>amateur_Burst_Injector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
