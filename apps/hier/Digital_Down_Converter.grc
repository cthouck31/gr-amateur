<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Digital_Down_Converter</value></param>
<param><key>category</key><value>[Amateur]</value></param>
<param><key>description</key><value>Performs down conversion, filtering, and resampling. Input sample rate remains fixed, output sample rate can be adjusted between (Fs_i/2^(floor(log2(Fs_i/Fs_o))) / 2, Fs_i/2^(floor(log2(Fs_i/Fs_o)))].</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Digital Down Converter (DDC)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Phi</value></param>
<param><key>value</key><value>2*math.pi*F_nco/float(Fs_i)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>Fs_i / float(Fs_o)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_arb</value></param>
<param><key>value</key><value>R/float(R_int)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_int</value></param>
<param><key>value</key><value>int(2**int(math.log(R)/math.log(2)))</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>decimTaps</value></param>
<param><key>cutoff_freq</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>R_int</value></param>
<param><key>width</key><value>0.1</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filtLen</value></param>
<param><key>value</key><value>len(decimTaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hbLen</value></param>
<param><key>value</key><value>len(hbTaps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>hbTaps</value></param>
<param><key>cutoff_freq</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>2.0</value></param>
<param><key>width</key><value>0.075</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>F_nco</value></param>
<param><key>label</key><value>NCO Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fs_i</value></param>
<param><key>label</key><value>Input Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Fs_o</value></param>
<param><key>label</key><value>Output Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>960000</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>-Phi</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>R_int</value></param>
<param><key>taps</key><value>decimTaps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>hbTaps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>64</value></param>
<param><key>rrate</key><value>2.0 / R_arb</value></param>
<param><key>atten</key><value>80.0</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
