<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AX25_Framer</value></param>
<param><key>category</key><value>[Amateur]</value></param>
<param><key>description</key><value>Block that takes in a PDU (packed bytes) and outputs a framed AX.25 packet as a PDU (unpacked bytes, w/CRC). Requires the 'Tagged NRZI Encoder' block from gr-amateur.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AX.25 Framer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frameTag</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>numPost_</value></param>
<param><key>value</key><value>max([1, numPost])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>numRevs_</value></param>
<param><key>value</key><value>max([1, numRevs])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[0, 1, 1, 1, 1, 1, 1, 0]</value></param>
</block>
<block>
<key>amateur_Tagged_Nrzi_Encoder</key>
<param><key>id</key><value>amateur_Tagged_Nrzi_Encoder_0</value></param>
<param><key>frameTag</key><value>frameTag</value></param>
<param><key>init</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>frameTag</value></param>
<param><key>packet_len</key><value>len(preamble) * numRevs_</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>frameTag</value></param>
<param><key>packet_len</key><value>len(preamble) * numPost_</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>frameTag</value></param>
<param><key>ninputs</key><value>3</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>frameTag</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(preamble * numRevs_)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(preamble * numPost_)</value></param>
</block>
<block>
<key>digital_hdlc_framer_pb</key>
<param><key>id</key><value>digital_hdlc_framer_pb_0</value></param>
<param><key>frame_tag_name</key><value>frameTag</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numPost</value></param>
<param><key>label</key><value>Postamble Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numRevs</value></param>
<param><key>label</key><value>Preamble Repetitions</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>amateur_Tagged_Nrzi_Encoder_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>amateur_Tagged_Nrzi_Encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_framer_pb_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_hdlc_framer_pb_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
