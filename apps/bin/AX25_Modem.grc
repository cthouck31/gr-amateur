<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AX25_Modem</value></param>
<param><key>author</key><value>cthouck31</value></param>
<param><key>category</key><value>[Amateur]</value></param>
<param><key>description</key><value>Modem for communicating via AX.25 w/ AFSK1200 modulation (APRS, etc).</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>AX.25 - AFSK1200 Modem</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_bitRate</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1200.0</value></param>
<param><key>option</key><value>bitRate</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_dcInsert</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>dcInsert</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_filterSyms</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>7</value></param>
<param><key>option</key><value>filterSyms</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_frameTag</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tx_len"</value></param>
<param><key>option</key><value>frameTag</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_markFreq</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1200.0</value></param>
<param><key>option</key><value>markFreq</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_rolloff</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>option</key><value>rolloff</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_spaceFreq</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>2200.0</value></param>
<param><key>option</key><value>spaceFreq</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ax25_ipAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>ipAddr</value></param>
<param><key>section</key><value>AX25</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ax25_ipPort</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>15331</value></param>
<param><key>option</key><value>ipPort</value></param>
<param><key>section</key><value>AX25</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ax25_mtu</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>option</key><value>mtu</value></param>
<param><key>section</key><value>AX25</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ax25_numPostambles</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>2</value></param>
<param><key>option</key><value>numPostambles</value></param>
<param><key>section</key><value>AX25</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ax25_numPreambles</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>40</value></param>
<param><key>option</key><value>numPreambles</value></param>
<param><key>section</key><value>AX25</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>csma_avgAlpha</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>option</key><value>avgAlpha</value></param>
<param><key>section</key><value>CSMA</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>csma_enable</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>enable</value></param>
<param><key>section</key><value>CSMA</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>csma_noiseAlpha</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.00001</value></param>
<param><key>option</key><value>noiseAlpha</value></param>
<param><key>section</key><value>CSMA</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>csma_snrThreshold</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>2.0</value></param>
<param><key>option</key><value>snrThreshold</value></param>
<param><key>section</key><value>CSMA</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_bb_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18730"</value></param>
<param><key>option</key><value>bb_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_cs_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18736"</value></param>
<param><key>option</key><value>cs_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_recv_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18733"</value></param>
<param><key>option</key><value>recv_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_rxCtrl_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18738"</value></param>
<param><key>option</key><value>rxCtrl_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_sent_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18734"</value></param>
<param><key>option</key><value>sent_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_snr_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18731"</value></param>
<param><key>option</key><value>snr_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_stats_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18735"</value></param>
<param><key>option</key><value>stats_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_syms_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18732"</value></param>
<param><key>option</key><value>syms_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_txCtrl_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18737"</value></param>
<param><key>option</key><value>txCtrl_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demod_agcAttack</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>option</key><value>agcAttack</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demod_agcDecay</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>option</key><value>agcAttack</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demod_agcEnable</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1</value></param>
<param><key>option</key><value>agcEnable</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demod_pllFreqMax</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>2.0*3.1415926 / 20.0</value></param>
<param><key>option</key><value>pllFreqMax</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>demod_pllLoopBw</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>2.0*3.1415926 / 350.0</value></param>
<param><key>option</key><value>pllLoopBw</value></param>
<param><key>section</key><value>Demod</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_nco</value></param>
<param><key>value</key><value>rx_fs/4.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logLvl</value></param>
<param><key>value</key><value>{"info": logging.INFO, "debug": logging.DEBUG, "warning": logging.WARNING, "warn": logging.WARN, "error": logging.ERROR}.get(logLevel.lower(), logging.INFO)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rootLogger</value></param>
<param><key>value</key><value>amateur.setupLogging(level=logLvl)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_ant</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"RX"</value></param>
<param><key>option</key><value>ant</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_bbGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bbGain</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_bw</value></param>
<param><key>config_file</key><value>/home/cth/workspace/ham/gr-amateur/config/aprs-tx_hackrf-rx_rtlsdr.conf</value></param>
<param><key>value</key><value>0.1e6</value></param>
<param><key>option</key><value>bw</value></param>
<param><key>section</key><value>[Receive]</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_deviceArgs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>""</value></param>
<param><key>option</key><value>deviceArgs</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_fs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>30.72e6/16</value></param>
<param><key>option</key><value>fs</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_ifGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ifGain</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_ppm</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>51</value></param>
<param><key>option</key><value>ppm</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_rfGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>60</value></param>
<param><key>option</key><value>rfGain</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>settings</value></param>
<param><key>value</key><value>settings_1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>settings_0</value></param>
<param><key>value</key><value>pmt.make_dict()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>settings_1</value></param>
<param><key>value</key><value>pmt.dict_add(settings_0, pmt.intern("rx_freq"), pmt.from_float(rx_freq))</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_ant</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
<param><key>option</key><value>ant</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_bbGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>bbGain</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_bw</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>0.1e6</value></param>
<param><key>option</key><value>bw</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_deviceArgs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>""</value></param>
<param><key>option</key><value>deviceArgs</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_fs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>30.72e6/16</value></param>
<param><key>option</key><value>fs</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_ifGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>10.0</value></param>
<param><key>option</key><value>ifGain</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_ppm</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>26</value></param>
<param><key>option</key><value>ppm</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>tx_rfGain</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>30</value></param>
<param><key>option</key><value>rfGain</value></param>
<param><key>section</key><value>Transmit</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>AX25_AFSK1200_Modulator</key>
<param><key>id</key><value>AX25_AFSK1200_Modulator_0</value></param>
<param><key>Rs</key><value>afsk_bitRate</value></param>
<param><key>comment</key><value>AX.25 - AFSK modulator.</value></param>
<param><key>dcInsert</key><value>afsk_dcInsert</value></param>
<param><key>frameTag</key><value>afsk_frameTag</value></param>
<param><key>Mark</key><value>afsk_markFreq</value></param>
<param><key>Fs</key><value>tx_fs</value></param>
<param><key>numPost</key><value>ax25_numPostambles</value></param>
<param><key>numRevs</key><value>ax25_numPreambles</value></param>
<param><key>alpha</key><value>afsk_rolloff</value></param>
<param><key>numSyms</key><value>afsk_filterSyms</value></param>
<param><key>Space</key><value>afsk_spaceFreq</value></param>
</block>
<block>
<key>AX25_AFSK_Demodulator</key>
<param><key>id</key><value>AX25_AFSK_Demodulator_0</value></param>
<param><key>Rs</key><value>afsk_bitRate</value></param>
<param><key>comment</key><value>AX.25 - AFSK Demodulator.</value></param>
<param><key>frameTag</key><value>afsk_frameTag</value></param>
<param><key>Fs</key><value>rx_fs</value></param>
<param><key>Mark</key><value>afsk_markFreq</value></param>
<param><key>loopBw</key><value>demod_pllLoopBw</value></param>
<param><key>lockFreq</key><value>demod_pllFreqMax</value></param>
<param><key>alpha</key><value>afsk_rolloff</value></param>
<param><key>numSyms</key><value>afsk_filterSyms</value></param>
<param><key>Space</key><value>afsk_spaceFreq</value></param>
</block>
<block>
<key>amateur_KISS_TNC</key>
<param><key>id</key><value>amateur_KISS_TNC_0</value></param>
<param><key>bitrate</key><value>afsk_bitRate</value></param>
<param><key>csma</key><value>1</value></param>
<param><key>comment</key><value>KISS TNC controller.</value></param>
<param><key>numPost</key><value>ax25_numPostambles</value></param>
<param><key>numPre</key><value>ax25_numPreambles</value></param>
<param><key>rxGain</key><value>rx_rfGain</value></param>
<param><key>portNum</key><value>0</value></param>
<param><key>txGain</key><value>tx_rfGain</value></param>
</block>
<block>
<key>amateur_Serial_Radio_Controller</key>
<param><key>id</key><value>amateur_Serial_Radio_Controller_0</value></param>
<param><key>speed</key><value>9600</value></param>
<param><key>device</key><value>"/dev/ttyACM0"</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>demod_agcAttack if (demod_agcEnable) else 0.0</value></param>
<param><key>comment</key><value>Automatic gain control.</value></param>
<param><key>decay_rate</key><value>demod_agcDecay if (demod_agcEnable) else 0.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0.98</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>0x01 if (csma_enable) else 0x00</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>settings</value></param>
<param><key>period</key><value>250</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>20.0/math.log(10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>-2*math.pi*f_nco/rx_fs</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>comment</key><value>AX.25 interface input.</value></param>
<param><key>host</key><value>ax25_ipAddr</value></param>
<param><key>mtu</key><value>ax25_mtu</value></param>
<param><key>port</key><value>ax25_ipPort</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>comment</key><value>SNR estimation.</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>comment</key><value>SNR thresholding.</value></param>
<param><key>high</key><value>csma_snrThreshold</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>csma_snrThreshold</value></param>
</block>
<block>
<key>blocks_transcendental</key>
<param><key>id</key><value>blocks_transcendental_0</value></param>
<param><key>name</key><value>log</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_transcendental</key>
<param><key>id</key><value>blocks_transcendental_0_0</value></param>
<param><key>name</key><value>log</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>configFile</value></param>
<param><key>label</key><value>Configuration File</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"~/.config/gr-amateur/AX25_Modem-HackRF-RTLSDR.ini"</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import logging; logging.basicConfig()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0_0</value></param>
<param><key>import</key><value>import amateur</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>allow_tcxo_dac</key><value>1</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>dacVal</key><value>125</value></param>
<param><key>digital_bandw_ch0</key><value>1e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>tx_rfGain</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>rf_freq</key><value>tx_freq</value></param>
<param><key>samp_rate</key><value>tx_fs</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>1</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>30.72e6/(2**4)</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>rx_rfGain</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>nco_freq_ch0</key><value>f_nco</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>rx_freq</value></param>
<param><key>samp_rate</key><value>rx_fs</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>logLevel</value></param>
<param><key>label</key><value>Log Level</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"debug"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>"Transmitter Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>"Receiver Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>"AX.25 Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>"AFSK Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>"Demodulator Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>"CSMA Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0_0</value></param>
<param><key>note</key><value>"Debug Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>"Carrier Sense"</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>csma_noiseAlpha</value></param>
<param><key>comment</key><value>Noise averaging (long term).</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>csma_avgAlpha</value></param>
<param><key>comment</key><value>Magnitude averaging (short term).</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>comment</key><value>Carrier sense.</value></param>
<param><key>stream_id</key><value>csense</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>tnc_resp</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>recv</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>pll</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>syms</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1</value></param>
<param><key>stream_id</key><value>mag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>phi</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1_1</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>trigger</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2</value></param>
<param><key>stream_id</key><value>sent</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1</value></param>
<param><key>stream_id</key><value>tx_cmd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0</value></param>
<param><key>stream_id</key><value>rx_cmd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>stats</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>csense</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>comment</key><value>KISS TNC responses.</value></param>
<param><key>stream_id</key><value>tnc_resp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>recv</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>recv</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>sent</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>csense</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0_1</value></param>
<param><key>stream_id</key><value>stats</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>stream_id</key><value>rx_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_2</value></param>
<param><key>stream_id</key><value>tx_cmd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>comment</key><value>Baseband signal.</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0</value></param>
<param><key>comment</key><value>Baseband signal.</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0</value></param>
<param><key>comment</key><value>SNR.</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0_0</value></param>
<param><key>comment</key><value>Symbols.</value></param>
<param><key>stream_id</key><value>syms</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>debug_recv_zmqAddr</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>debug_sent_zmqAddr</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0_0</value></param>
<param><key>address</key><value>debug_stats_zmqAddr</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>debug_bb_zmqAddr</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_0</value></param>
<param><key>address</key><value>debug_snr_zmqAddr</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_0_0</value></param>
<param><key>address</key><value>debug_syms_zmqAddr</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_0_0_0</value></param>
<param><key>address</key><value>debug_cs_zmqAddr</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>debug_txCtrl_zmqAddr</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>debug_rxCtrl_zmqAddr</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<connection><source_block_id>AX25_AFSK1200_Modulator_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AX25_AFSK_Demodulator_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AX25_AFSK_Demodulator_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>AX25_AFSK_Demodulator_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AX25_AFSK_Demodulator_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>amateur_Serial_Radio_Controller_0</sink_block_id><source_key>ext_cmd</source_key><sink_key>cmd</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0</sink_block_id><source_key>rx_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>tnc_resp</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>virtual_sink_0_0_1</sink_block_id><source_key>tx_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>AX25_AFSK1200_Modulator_0</sink_block_id><source_key>tx_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>amateur_KISS_TNC_0</source_block_id><sink_block_id>virtual_sink_0_0_0_2</sink_block_id><source_key>tx_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>AX25_AFSK_Demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>amateur_KISS_TNC_0</sink_block_id><source_key>pdus</source_key><sink_key>tnc_req</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_transcendental_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_transcendental_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_transcendental_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_transcendental_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>amateur_KISS_TNC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>amateur_KISS_TNC_0</sink_block_id><source_key>out</source_key><sink_key>rx_data</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0_1</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>limesdr_source_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_2</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>limesdr_source_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
</flow_graph>
