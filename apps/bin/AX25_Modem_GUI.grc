<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>AX25_Modem_GUI</value></param>
<param><key>author</key><value>cthouck31</value></param>
<param><key>description</key><value>GUI for the AX.25 - AFSK1200 Modem application.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>AX.25 - AFSK1200 Modem GUI</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_bb</value></param>
<param><key>value</key><value>min([rx_fs/afsk_bitRate, 20]) * afsk_bitRate</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>afsk_bitRate</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1200.0</value></param>
<param><key>option</key><value>bitRate</value></param>
<param><key>section</key><value>AFSK</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_bb_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18730"</value></param>
<param><key>option</key><value>bb_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_cs_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18736"</value></param>
<param><key>option</key><value>cs_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_recv_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18733"</value></param>
<param><key>option</key><value>recv_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_rxCtrl_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18738"</value></param>
<param><key>option</key><value>rxCtrl_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_sent_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18734"</value></param>
<param><key>option</key><value>sent_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_snr_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18731"</value></param>
<param><key>option</key><value>snr_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_stats_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18735"</value></param>
<param><key>option</key><value>stats_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_syms_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18732"</value></param>
<param><key>option</key><value>syms_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>debug_txCtrl_zmqAddr</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:18737"</value></param>
<param><key>option</key><value>txCtrl_zmqAddr</value></param>
<param><key>section</key><value>Debug</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logLvl</value></param>
<param><key>value</key><value>{"info": logging.INFO, "debug": logging.DEBUG, "warning": logging.WARNING, "warn": logging.WARN, "error": logging.ERROR}.get(logLevel.lower(), logging.INFO)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rootLogger</value></param>
<param><key>value</key><value>amateur.setupLogging(level=logLvl)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_deviceArgs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>""</value></param>
<param><key>option</key><value>deviceArgs</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rx_fs</value></param>
<param><key>config_file</key><value>configFile</value></param>
<param><key>value</key><value>1.92e6</value></param>
<param><key>option</key><value>fs</value></param>
<param><key>section</key><value>Receive</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>msgTab@0: 0, 4, 1, 4</value></param>
<param><key>label</key><value>"Receive"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>msgTab@0: 0, 0, 1, 4</value></param>
<param><key>label</key><value>"Transmit"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0</value></param>
<param><key>value</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>statTab@0: 2, 0, 1, 4</value></param>
<param><key>label</key><value>"Modem Status"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>amateur_AX25_Packet_Decoder</key>
<param><key>id</key><value>amateur_AX25_Packet_Decoder_0</value></param>
</block>
<block>
<key>amateur_AX25_Packet_Decoder</key>
<param><key>id</key><value>amateur_AX25_Packet_Decoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>amateur_Message_To_Json</key>
<param><key>id</key><value>amateur_Message_To_Json_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>amateur_qtgui_Embedded_Terminal</key>
<param><key>id</key><value>amateur_qtgui_Embedded_Terminal_0</value></param>
<param><key>blacklist</key><value>["exit", "reboot", "poweroff", "rm .", "rm *", "rm -rf *", "rm -rf ."]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>msgTab@1: 0, 0, 1, 1</value></param>
</block>
<block>
<key>amateur_qtgui_Terminal_Sink</key>
<param><key>id</key><value>amateur_qtgui_Terminal_Sink_1</value></param>
<param><key>append</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fontSize</key><value>10</value></param>
<param><key>gui_hint</key><value>msgTab@0: 1, 4, 4, 4</value></param>
<param><key>label</key><value>"Receive"</value></param>
</block>
<block>
<key>amateur_qtgui_Terminal_Sink</key>
<param><key>id</key><value>amateur_qtgui_Terminal_Sink_1_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fontSize</key><value>10</value></param>
<param><key>gui_hint</key><value>msgTab@0: 1, 0, 4, 4</value></param>
<param><key>label</key><value>"Transmit"</value></param>
</block>
<block>
<key>amateur_qtgui_Terminal_Sink</key>
<param><key>id</key><value>amateur_qtgui_Terminal_Sink_1_0_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fontSize</key><value>10</value></param>
<param><key>gui_hint</key><value>statTab@0: 3, 0, 7, 4</value></param>
<param><key>label</key><value>"Modem Status"</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>configFile</value></param>
<param><key>label</key><value>Configuration File</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"~/.config/gr-amateur/AX25_Modem-HackRF-RTLSDR.ini"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>ctrlTab</value></param>
<param><key>gui_hint</key><value>3, 6, 5, 2</value></param>
<param><key>label0</key><value>Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import logging; logging.basicConfig()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import amateur</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>logLevel</value></param>
<param><key>label</key><value>Log Level</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"debug"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>msgTab</value></param>
<param><key>gui_hint</key><value>8, 0, 8, 8</value></param>
<param><key>label0</key><value>Messages</value></param>
<param><key>label1</key><value>Console</value></param>
<param><key>label2</key><value>Beacon</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>"Spectrum Tab"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>"Receiver Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>"AFSK Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0_0</value></param>
<param><key>note</key><value>"Debug Settings"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>"Time Tab"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2</value></param>
<param><key>note</key><value>"Message Tab"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2_0</value></param>
<param><key>note</key><value>"Statistics Tab"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2_0_0</value></param>
<param><key>note</key><value>"Control Tab"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>plotTab</value></param>
<param><key>gui_hint</key><value>0, 0, 8, 6</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>ctrlTab@0: 0, 0, 1, 1</value></param>
<param><key>key</key><value>"freq"</value></param>
<param><key>label</key><value>"TX - Frequency"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0</value></param>
<param><key>gui_hint</key><value>ctrlTab@0: 1, 0, 1, 1</value></param>
<param><key>key</key><value>"freq"</value></param>
<param><key>label</key><value>"RX - Frequency"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0_0</value></param>
<param><key>gui_hint</key><value>ctrlTab@0: 3, 0, 1, 1</value></param>
<param><key>key</key><value>"gain"</value></param>
<param><key>label</key><value>"RX - Gain"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_1</value></param>
<param><key>gui_hint</key><value>ctrlTab@0: 2, 0, 1, 1</value></param>
<param><key>key</key><value>"gain"</value></param>
<param><key>label</key><value>"TX - Gain"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>Fs_bb</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>plotTab@0: 0, 0, 3, 8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>""</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
<param><key>units</key><value>"dB"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>statTab@0: 0, 0, 1, 4</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>"{:8s}".format("SNR")</value></param>
<param><key>unit1</key><value>"dB"</value></param>
<param><key>label2</key><value>"{:8s}".format("CS")</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>-5</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>plotTab@1: 0, 0, 4, 8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"SNR"</value></param>
<param><key>size</key><value>int(Fs_bb * 2)</value></param>
<param><key>srate</key><value>Fs_bb</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>""</value></param>
<param><key>ymax</key><value>30</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>plotTab@1: 4, 0, 4, 8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Symbols"</value></param>
<param><key>size</key><value>int(afsk_bitRate * 2)</value></param>
<param><key>srate</key><value>afsk_bitRate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>""</value></param>
<param><key>ymax</key><value>1.25</value></param>
<param><key>ymin</key><value>-1.25</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>Fs_bb</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>plotTab@0: 3, 0, 5, 8</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.025</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>statTab</value></param>
<param><key>gui_hint</key><value>0, 6, 3, 2</value></param>
<param><key>label0</key><value>Statistics</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>rx_freq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>comment</key><value>SNR.</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rx_freq</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0_0</value></param>
<param><key>address</key><value>debug_txCtrl_zmqAddr</value></param>
<param><key>comment</key><value>TX Control.</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0_0_0</value></param>
<param><key>address</key><value>debug_rxCtrl_zmqAddr</value></param>
<param><key>comment</key><value>RX Control.</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>debug_recv_zmqAddr</value></param>
<param><key>comment</key><value>Receive.</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>debug_sent_zmqAddr</value></param>
<param><key>comment</key><value>Transmit.</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_0</value></param>
<param><key>address</key><value>debug_stats_zmqAddr</value></param>
<param><key>comment</key><value>Transmit.</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>debug_bb_zmqAddr</value></param>
<param><key>comment</key><value>Baseband samples.</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_0</value></param>
<param><key>address</key><value>debug_snr_zmqAddr</value></param>
<param><key>comment</key><value>SNR.</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_0_0</value></param>
<param><key>address</key><value>debug_syms_zmqAddr</value></param>
<param><key>comment</key><value>Symbols.</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_0_0_0</value></param>
<param><key>address</key><value>debug_cs_zmqAddr</value></param>
<param><key>comment</key><value>Carrier sense.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>timeout</key><value>5</value></param>
</block>
<connection><source_block_id>amateur_AX25_Packet_Decoder_0</source_block_id><sink_block_id>amateur_qtgui_Terminal_Sink_1</sink_block_id><source_key>str</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>amateur_AX25_Packet_Decoder_0_0</source_block_id><sink_block_id>amateur_qtgui_Terminal_Sink_1_0</sink_block_id><source_key>str</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_1</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>amateur_AX25_Packet_Decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>amateur_AX25_Packet_Decoder_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_0</source_block_id><sink_block_id>amateur_Message_To_Json_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_0_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
