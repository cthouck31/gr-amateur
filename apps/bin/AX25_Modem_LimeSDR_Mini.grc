options:
  parameters:
    description: AFSK1200 AX.25 modem using the LimeSDR Mini hardware.
    generate_options: qt_gui
    id: AX25_Modem_LimeSDR_Mini
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: AX.25 Modem - LimeSDR Mini
  states: {}

blocks:
- name: afsk_bitRate
  id: variable_config
  parameters:
    config_file: configFile
    option: bitRate
    section: AFSK
    type: real
    value: '1200.0'
    writeback: None
  states: {}
- name: afsk_dcInsert
  id: variable_config
  parameters:
    config_file: configFile
    option: dcInsert
    section: AFSK
    type: int
    value: '1'
    writeback: None
  states: {}
- name: afsk_filterSyms
  id: variable_config
  parameters:
    config_file: configFile
    option: filterSyms
    section: AFSK
    type: int
    value: '7'
    writeback: None
  states: {}
- name: afsk_frameTag
  id: variable_config
  parameters:
    config_file: configFile
    option: frameTag
    section: AFSK
    type: string
    value: '"tx_len"'
    writeback: None
  states: {}
- name: afsk_markFreq
  id: variable_config
  parameters:
    config_file: configFile
    option: markFreq
    section: AFSK
    type: real
    value: '1200.0'
    writeback: None
  states: {}
- name: afsk_rolloff
  id: variable_config
  parameters:
    config_file: configFile
    option: rolloff
    section: AFSK
    type: real
    value: '0.7'
    writeback: None
  states: {}
- name: afsk_spaceFreq
  id: variable_config
  parameters:
    config_file: configFile
    option: spaceFreq
    section: AFSK
    type: real
    value: '2200.0'
    writeback: None
  states: {}
- name: ax25_ipAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: ipAddr
    section: AX25
    type: string
    value: '"127.0.0.1"'
    writeback: None
  states: {}
- name: ax25_ipPort
  id: variable_config
  parameters:
    config_file: configFile
    option: ipPort
    section: AX25
    type: string
    value: '15331'
    writeback: None
  states: {}
- name: ax25_mtu
  id: variable_config
  parameters:
    config_file: configFile
    option: mtu
    section: AX25
    type: int
    value: '10000'
    writeback: None
  states: {}
- name: ax25_numPostambles
  id: variable_config
  parameters:
    config_file: configFile
    option: numPostambles
    section: AX25
    type: int
    value: '2'
    writeback: None
  states: {}
- name: ax25_numPreambles
  id: variable_config
  parameters:
    config_file: configFile
    option: numPreambles
    section: AX25
    type: int
    value: '40'
    writeback: None
  states: {}
- name: csma_avgAlpha
  id: variable_config
  parameters:
    config_file: configFile
    option: avgAlpha
    section: CSMA
    type: real
    value: '0.01'
    writeback: None
  states: {}
- name: csma_enable
  id: variable_config
  parameters:
    config_file: configFile
    option: enable
    section: CSMA
    type: int
    value: '1'
    writeback: None
  states: {}
- name: csma_noiseAlpha
  id: variable_config
  parameters:
    config_file: configFile
    option: noiseAlpha
    section: CSMA
    type: real
    value: '0.00001'
    writeback: None
  states: {}
- name: csma_snrThreshold
  id: variable_config
  parameters:
    config_file: configFile
    option: snrThreshold
    section: CSMA
    type: real
    value: '2.0'
    writeback: None
  states: {}
- name: debug_bb_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: bb_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18730"'
    writeback: None
  states: {}
- name: debug_cs_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: cs_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18736"'
    writeback: None
  states: {}
- name: debug_recv_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: recv_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18733"'
    writeback: None
  states: {}
- name: debug_rxCtrl_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: rxCtrl_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18738"'
    writeback: None
  states: {}
- name: debug_sent_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: sent_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18734"'
    writeback: None
  states: {}
- name: debug_snr_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: snr_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18731"'
    writeback: None
  states: {}
- name: debug_stats_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: stats_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18735"'
    writeback: None
  states: {}
- name: debug_syms_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: syms_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18732"'
    writeback: None
  states: {}
- name: debug_txCtrl_zmqAddr
  id: variable_config
  parameters:
    config_file: configFile
    option: txCtrl_zmqAddr
    section: Debug
    type: string
    value: '"tcp://127.0.0.1:18737"'
    writeback: None
  states: {}
- name: demod_agcAttack
  id: variable_config
  parameters:
    config_file: configFile
    option: agcAttack
    section: Demod
    type: real
    value: '0.1'
    writeback: None
  states: {}
- name: demod_agcDecay
  id: variable_config
  parameters:
    config_file: configFile
    option: agcAttack
    section: Demod
    type: real
    value: '0.01'
    writeback: None
  states: {}
- name: demod_agcEnable
  id: variable_config
  parameters:
    config_file: configFile
    option: agcEnable
    section: Demod
    type: int
    value: '1'
    writeback: None
  states: {}
- name: demod_pllFreqMax
  id: variable_config
  parameters:
    config_file: configFile
    option: pllFreqMax
    section: Demod
    type: real
    value: 2.0*3.1415926 / 20.0
    writeback: None
  states: {}
- name: demod_pllLoopBw
  id: variable_config
  parameters:
    config_file: configFile
    option: pllLoopBw
    section: Demod
    type: real
    value: 2.0*3.1415926 / 350.0
    writeback: None
  states: {}
- name: logLvl
  id: variable
  parameters:
    value: '{"info": logging.INFO, "debug": logging.DEBUG, "warning": logging.WARNING, "warn": logging.WARN, "error": logging.ERROR}.get(logLevel.lower(), logging.INFO)'
  states: {}
- name: rootLogger
  id: variable
  parameters:
    value: amateur.setupLogging(level=logLvl)
  states: {}
- name: rx_ant
  id: variable_config
  parameters:
    config_file: configFile
    option: ant
    section: Receive
    type: string
    value: '"RX"'
    writeback: None
  states: {}
- name: rx_bbGain
  id: variable_config
  parameters:
    config_file: configFile
    option: bbGain
    section: Receive
    type: real
    value: '0'
    writeback: None
  states: {}
- name: rx_bw
  id: variable_config
  parameters:
    config_file: /home/cth/workspace/ham/gr-amateur/config/aprs-tx_hackrf-rx_rtlsdr.conf
    option: bw
    section: '[Receive]'
    type: real
    value: 0.1e6
    writeback: None
  states: {}
- name: rx_deviceArgs
  id: variable_config
  parameters:
    config_file: configFile
    option: deviceArgs
    section: Receive
    type: string
    value: '""'
    writeback: None
  states: {}
- name: rx_freq
  id: variable_config
  parameters:
    config_file: configFile
    option: freq
    section: Receive
    type: real
    value: 144.390e6
    writeback: None
  states: {}
- name: rx_fs
  id: variable_config
  parameters:
    config_file: configFile
    option: fs
    section: Receive
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: rx_ifGain
  id: variable_config
  parameters:
    config_file: configFile
    option: ifGain
    section: Receive
    type: real
    value: '0'
    writeback: None
  states: {}
- name: rx_ppm
  id: variable_config
  parameters:
    config_file: configFile
    option: ppm
    section: Receive
    type: real
    value: '51'
    writeback: None
  states: {}
- name: rx_rfGain
  id: variable_config
  parameters:
    config_file: configFile
    option: rfGain
    section: Receive
    type: real
    value: '70.0'
    writeback: None
  states: {}
- name: settings
  id: variable
  parameters:
    value: settings_1
  states: {state: disabled}
- name: settings_0
  id: variable
  parameters:
    value: pmt.make_dict()
  states: {state: disabled}
- name: settings_1
  id: variable
  parameters:
    value: pmt.dict_add(settings_0, pmt.intern("rx_freq"), pmt.from_float(rx_freq))
  states: {state: disabled}
- name: tx_ant
  id: variable_config
  parameters:
    config_file: configFile
    option: ant
    section: Transmit
    type: string
    value: '"TX/RX"'
    writeback: None
  states: {}
- name: tx_bbGain
  id: variable_config
  parameters:
    config_file: configFile
    option: bbGain
    section: Transmit
    type: real
    value: '0'
    writeback: None
  states: {}
- name: tx_bw
  id: variable_config
  parameters:
    config_file: configFile
    option: bw
    section: Transmit
    type: real
    value: 0.1e6
    writeback: None
  states: {}
- name: tx_deviceArgs
  id: variable_config
  parameters:
    config_file: configFile
    option: deviceArgs
    section: Transmit
    type: string
    value: '""'
    writeback: None
  states: {}
- name: tx_freq
  id: variable_config
  parameters:
    config_file: configFile
    option: freq
    section: Transmit
    type: real
    value: 144.390e6
    writeback: None
  states: {}
- name: tx_fs
  id: variable_config
  parameters:
    config_file: configFile
    option: fs
    section: Transmit
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: tx_ifGain
  id: variable_config
  parameters:
    config_file: configFile
    option: ifGain
    section: Transmit
    type: real
    value: '0'
    writeback: None
  states: {}
- name: tx_ppm
  id: variable_config
  parameters:
    config_file: configFile
    option: ppm
    section: Transmit
    type: real
    value: '26'
    writeback: None
  states: {}
- name: tx_rfGain
  id: variable_config
  parameters:
    config_file: configFile
    option: rfGain
    section: Transmit
    type: real
    value: '10'
    writeback: None
  states: {}
- name: AX25_AFSK1200_Modulator_0
  id: AX25_AFSK1200_Modulator
  parameters:
    Fs: tx_fs
    Mark: afsk_markFreq
    Rs: afsk_bitRate
    Space: afsk_spaceFreq
    alpha: afsk_rolloff
    comment: AX.25 - AFSK modulator.
    dcInsert: afsk_dcInsert
    frameTag: afsk_frameTag
    numPost: ax25_numPostambles
    numRevs: ax25_numPreambles
    numSyms: afsk_filterSyms
  states: {state: disabled}
- name: AX25_AFSK_Demodulator_0
  id: AX25_AFSK_Demodulator
  parameters:
    Fs: rx_fs
    Mark: afsk_markFreq
    Rs: afsk_bitRate
    Space: afsk_spaceFreq
    alpha: afsk_rolloff
    comment: AX.25 - AFSK Demodulator.
    frameTag: afsk_frameTag
    lockFreq: demod_pllFreqMax
    loopBw: demod_pllLoopBw
    numSyms: afsk_filterSyms
  states: {state: disabled}
- name: amateur_KISS_TNC_0
  id: amateur_KISS_TNC
  parameters:
    bitRate: '1200.0'
    comment: KISS TNC controller.
    csma: 'True'
    numPostambles: '1'
    numPreambles: '1'
    portNum: '0'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: demod_agcAttack if (demod_agcEnable) else 0.0
    comment: Automatic gain control.
    decay_rate: demod_agcDecay if (demod_agcEnable) else 0.0
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: 0x01 if (csma_enable) else 0x00
    type: byte
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 20.0/math.log(10)
    type: float
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: AX.25 interface input.
    host: ax25_ipAddr
    mtu: ax25_mtu
    port: ax25_ipPort
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: SNR estimation.
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: SNR thresholding.
    high: csma_snrThreshold
    init: '0'
    low: csma_snrThreshold
  states: {state: disabled}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: log
    type: float
  states: {state: disabled}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: log
    type: float
  states: {state: disabled}
- name: configFile
  id: parameter
  parameters:
    label: Configuration File
    value: '"~/.config/gr-amateur/AX25_Modem-LimeSDRMini.ini"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import logging; logging.basicConfig()
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import amateur
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '1'
    analog_bandw_ch0: max([5e6, tx_bw])
    calibr_bandw_ch0: max([5e6, 8*afsk_bitRate])
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: tx_fs
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_rfGain)
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_freq
    samp_rate: tx_fs
    serial: tx_deviceArgs
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '1'
    analog_bandw_ch0: max([1.5e6, rx_bw])
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: max([2.5e6, 8*afsk_bitRate])
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: rx_fs
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_rfGain)
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: rx_freq
    samp_rate: rx_fs
    serial: rx_deviceArgs
  states: {state: disabled}
- name: logLevel
  id: parameter
  parameters:
    label: Log Level
    value: '"debug"'
  states: {}
- name: note_0
  id: note
  parameters:
    note: '"Transmitter Settings"'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: '"Receiver Settings"'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: '"AX.25 Settings"'
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: '"AFSK Settings"'
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: '"Demodulator Settings"'
  states: {}
- name: note_0_0_0_0_0_0
  id: note
  parameters:
    note: '"CSMA Settings"'
  states: {}
- name: note_0_0_0_0_0_0_0
  id: note
  parameters:
    note: '"Debug Settings"'
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: '"Carrier Sense"'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: csma_noiseAlpha
    comment: Noise averaging (long term).
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: csma_avgAlpha
    comment: Magnitude averaging (short term).
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: Carrier sense.
    stream_id: csense
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tnc_resp
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: recv
  states: {state: disabled}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: bb
  states: {state: disabled}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: pll
  states: {state: disabled}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: syms
  states: {state: disabled}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: mag
  states: {state: disabled}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: phi
  states: {state: disabled}
- name: virtual_sink_0_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: snr
  states: {state: disabled}
- name: virtual_sink_0_0_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: trigger
  states: {state: disabled}
- name: virtual_sink_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: sent
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: stats
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: csense
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: KISS TNC responses.
    stream_id: tnc_resp
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: recv
  states: {state: disabled}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: recv
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: sent
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: csense
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: stats
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    comment: Baseband signal.
    stream_id: bb
  states: {state: disabled}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    comment: Baseband signal.
    stream_id: bb
  states: {state: disabled}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    comment: SNR.
    stream_id: snr
  states: {state: disabled}
- name: virtual_source_0_0_1_0_0_0
  id: virtual_source
  parameters:
    comment: Symbols.
    stream_id: syms
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: debug_recv_zmqAddr
    timeout: '10'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: debug_sent_zmqAddr
    timeout: '10'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: debug_stats_zmqAddr
    timeout: '10'
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: debug_bb_zmqAddr
    timeout: '10'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: debug_snr_zmqAddr
    timeout: '10'
    type: float
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: debug_syms_zmqAddr
    timeout: '10'
    type: float
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: debug_cs_zmqAddr
    timeout: '10'
    type: byte
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: debug_txCtrl_zmqAddr
    comment: TX Control.
    timeout: '10'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: debug_rxCtrl_zmqAddr
    comment: RX Control.
    timeout: '10'
  states: {state: disabled}

connections:
- [AX25_AFSK1200_Modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [AX25_AFSK_Demodulator_0, '0', virtual_sink_0_0_0, '0']
- [AX25_AFSK_Demodulator_0, '0', virtual_sink_0_0_0_0, '0']
- [AX25_AFSK_Demodulator_0, '1', virtual_sink_0_0_0_0_0, '0']
- [AX25_AFSK_Demodulator_0, '2', virtual_sink_0_0_0_0_0_0, '0']
- [amateur_KISS_TNC_0, modem_data, AX25_AFSK1200_Modulator_0, in]
- [amateur_KISS_TNC_0, modem_data, blocks_message_debug_0, print_pdu]
- [amateur_KISS_TNC_0, modem_data, virtual_sink_0_0_0_2, '0']
- [amateur_KISS_TNC_0, tnc_resp, virtual_sink_0_0, '0']
- [analog_agc2_xx_0, '0', AX25_AFSK_Demodulator_0, '0']
- [blocks_and_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_arg_0, '0', virtual_sink_0_0_0_1_0, '0']
- [blocks_complex_to_mag_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_uchar_0, '0', blocks_and_const_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0_0_1_1, '0']
- [blocks_null_source_0, '0', amateur_KISS_TNC_0, cs]
- [blocks_socket_pdu_0, pdus, amateur_KISS_TNC_0, tnc_req]
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', virtual_sink_0_0_0_1_1_0, '0']
- [blocks_transcendental_0, '0', blocks_sub_xx_0, '0']
- [blocks_transcendental_0_0, '0', blocks_sub_xx_0, '1']
- [limesdr_source_0, '0', analog_agc2_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_transcendental_0_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_transcendental_0, '0']
- [virtual_source_0_0, '0', blocks_socket_pdu_0, pdus]
- [virtual_source_0_0_1, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
